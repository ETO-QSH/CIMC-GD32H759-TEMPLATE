# Keil uVision project CIMC_GD32_Template.uvprojx, settings and files
target CIMC_GD32_Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CIMC_GD32_Template
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32H7XX
  c include: ..\CMSIS;..\CMSIS\GD\GD32H7xx\Include;..\Library\GD32H7xx_standard_peripheral\Include;..\Library\Utilites;..\HeaderFiles;..\User;..\Function;..\Driver\ENET\lwip\inc;..\Driver\ENET\lwip\inc\lwip;..\Driver\ENET\lwip\inc\netif;..\Driver\ENET\lwip_port;..\Driver\ENET\lwip_port\arch;..\Driver\ENET\lwip_port\FreeRTOS;..\Driver\FreeRTOS-10.3.1;..\Driver\FreeRTOS-10.3.1\include;..\Driver\FreeRTOS-10.3.1\portable;..\HardWare\ENTE;..\HardWare\FreeRTOS;..\HardWare\TIMER;..\HardWare\USART;..\User\inc;..\HardWare\ADC;..\HardWare\CAN;..\HardWare\extRTC;..\HardWare\I2C;..\HardWare\OLED;..\HardWare\RTC;..\HardWare\SDRAM;..\HardWare\SPI;..\HardWare\SPI_FLASH;..\HardWare\USART485_232
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
  group User
    ../User/src/: gd32h7xx_enet_eval.c gd32h7xx_it.c main.c netconf.c systick.c
  group HardWare
    ../HardWare/ENTE/: tcp_client.c tcp_server.c udp_tmp.c
    ../HardWare/FreeRTOS/: app_main.c
    ../HardWare/TIMER/: timer.c
    ../HardWare/USART/: usart.c
    ../HardWare/LED/: LED.c
    ../HardWare/ADC/: adc.c
    ../HardWare/CAN/: can.c
    ../HardWare/extRTC/: extRTC.c
    ../HardWare/I2C/: i2c.c
    ../HardWare/OLED/: OLED.c
    ../HardWare/RTC/: rtc.c
    ../HardWare/SDRAM/: exmc_sdram.c
    ../HardWare/SPI/: spi.c
    ../HardWare/SPI_FLASH/: SPI_FLASH.c
    ../HardWare/USART485_232/: usart485_232.c
  group Function
    ../Function/: Function.c
  group HeaderFiles
    ../HeaderFiles/: HeaderFiles.h
  group CMSIS
    ../CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Library
    ../Library/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group Startup
    ../CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group Readme
    ../01 Readme/: Readme.txt
  group lwip
    ../Driver/ENET/lwip/src/: altcp.c altcp_alloc.c altcp_tcp.c api_lib.c api_msg.c autoip.c def.c dhcp.c dns.c err.c etharp.c ethernet.c icmp.c if_api.c igmp.c inet_chksum.c init.c ip.c ip4.c ip4_addr.c ip4_frag.c mem.c memp.c netbuf.c netdb.c netif.c netifapi.c pbuf.c raw.c sockets.c stats.c sys.c tcp.c tcp_in.c tcp_out.c tcpip.c timeouts.c udp.c
  group lwip_port
    ../Driver/ENET/lwip_port/FreeRTOS/: ethernetif.c sys_arch.c
  group FreeRTOS
    ../Driver/FreeRTOS-10.3.1/: FreeRTOSConfig.h croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Driver/FreeRTOS-10.3.1/portable/: port.c heap_4.c
software components: CMSIS:CORE 5.6.0
